# Keil uVision project freertos_lpc1549.uvprojx, settings and files
target freertos_lpc1549xpresso (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos_lpc1549
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\software\freertos\freertos-plus\Source\FreeRTOS-Plus-CLI;..\..\..\..\..\software\freertos\freertoslpc;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_15xx\config_15xx;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549;..\..\..\examples\freertos\app;..\..\..\examples\freertos\shell;..\..\..\examples\freertos\arduino\ws_shield\accessory
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group freertos
    ../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group freertos-plus-cli
    ../../../../../software/freertos/freertos-plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group chip_lpc15xx
    ../../../../../software/lpc_core/lpc_chip/chip_common/: ring_buffer.c eeprom.c iap.c
    ../../../../../software/lpc_core/lpc_chip/chip_15xx/: adc_15xx.c crc_15xx.c sysctl_15xx.c clock_15xx.c gpio_15xx.c iocon_15xx.c swm_15xx.c chip_15xx.c pmu_15xx.c sysinit_15xx.c uart_15xx.c rtc_15xx.c ritimer_15xx.c wwdt_15xx.c dma_15xx.c stopwatch_15xx.c acmp_15xx.c dac_15xx.c spi_15xx.c i2cm_15xx.c i2c_common_15xx.c i2cs_15xx.c sct_15xx.c sct_pwm_15xx.c
  group board_lpc1549xpresso
    ../../../../../software/lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/: board.c board_sysinit.c
  group bsp
    ../../../startup_code/: keil_startup_lpc15xx.s sysinit.c
    ../../../../../software/freertos/freertoslpc/: bsp_ser.c bsp_i2c_rom.c
  group app
    ../../../examples/freertos/app/: app.c app_arduino.c
  group shell
    ../../../examples/freertos/shell/: UARTCommandConsole.c Sample-CLI-commands.c
  group accessory
    ../../../examples/freertos/arduino/ws_shield/accessory/: drv_lm75b.c drv_ssd1306.c ssd1306_font.c
software components: CMSIS:CORE 4.3.0
